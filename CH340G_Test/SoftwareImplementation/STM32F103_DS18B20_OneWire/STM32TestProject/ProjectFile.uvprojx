# Keil uVision project ProjectFile.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ProjectFile
  AfterMake: fromelf $PObjects\%L --disassemble --interleave=source  --text -c --output=outfile.lst
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --debug
  group Source Group 1
    ./: main.c DS18B20.h DS18B20.c GlobalHelperFunctions.h GlobalHelperFunctions.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
